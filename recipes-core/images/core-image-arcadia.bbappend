IMAGE_INSTALL:append:radxa-zero3w = " packagegroup-rockchip-multimedia"
