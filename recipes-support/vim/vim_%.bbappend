PACKAGECONFIG:remove = "gtkgui"